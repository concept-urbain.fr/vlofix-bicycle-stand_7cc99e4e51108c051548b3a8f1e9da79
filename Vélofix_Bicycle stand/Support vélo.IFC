Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Support vélo.IFC
Time: 2020-07-03T11:05:33
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: BOR M12 DIN1587 A2_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 7.77726; Area Measure: 0.210374; Volume Measure: 0.00100955

# IfcBuildingElementProxy: MULT-SCE-001_Default
In: Default Storey
Material: S235
